FILESEXTRAPATHS:prepend := "${THISDIR}/optee-os-fio:"

require recipes-security/optee/optee-os-fio_${PV}.bb
