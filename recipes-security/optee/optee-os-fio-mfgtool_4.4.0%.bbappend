require optee-os-fio-bsp-nxp-imx-mfgtool.inc
