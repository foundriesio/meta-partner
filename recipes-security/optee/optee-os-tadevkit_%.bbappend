require optee-os-variscite.inc
