# WARNING: gen-partition-bins-1.0-r0 do_compile: Task 'do_compile' depends on 'virtual/partconf:do_deploy' but 'virtual/partconf' is not in DEPENDS
DEPENDS += "virtual/partconf"
