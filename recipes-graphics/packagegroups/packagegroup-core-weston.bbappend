RDEPENDS:${PN}:remove:qcom = "weston-init"
