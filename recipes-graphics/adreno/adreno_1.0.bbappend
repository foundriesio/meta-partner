PROVIDES += "virtual/libgl"

RPROVIDES:${PN} += "libegl libgl libgles1 libgles2"
