OPENGL_PKGCONFIGS:qcom = "dri3"
