PACKAGECONFIG:append:qcom = " gallium"
