# doesn't extra correctly when usrmerge is enabled
FIRMWARE_PATH:sota = "/lib/firmware/brcm"
