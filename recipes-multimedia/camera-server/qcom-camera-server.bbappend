FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-cam-server-base.service-create-sockets-with-group-rw.patch"
