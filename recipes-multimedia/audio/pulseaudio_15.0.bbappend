USERADDSETSCENEDEPS:append = " useradd-qcom:do_populate_sysroot_setscene"
