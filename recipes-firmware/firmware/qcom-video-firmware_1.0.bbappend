FILES:${PN} += "${nonarch_base_libdir}/firmware/"
