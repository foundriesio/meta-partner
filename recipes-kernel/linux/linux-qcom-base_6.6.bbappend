require linux-qcom-lmp.inc
