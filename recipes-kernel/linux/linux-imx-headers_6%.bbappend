LIC_FILES_CHKSUM:tdx = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"
SRCBRANCH:tdx = "toradex_5.15-2.1.x-imx"
SRC_URI:tdx = "git://git.toradex.com/linux-toradex.git;protocol=https;branch=${SRCBRANCH}"
# Keep that one stable, i.e. use the exact git hash from the NXP BSP.
SRCREV:tdx = "36363d8623ba60858e2632b7d2b70dae932c9a8b"
