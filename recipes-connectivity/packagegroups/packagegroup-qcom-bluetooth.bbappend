# tool to edit bda nvm tag in /lib/firmware, not useful with sota/ostree
RDEPENDS:${PN}:remove:sota = "bluetooth-tools btftm"
