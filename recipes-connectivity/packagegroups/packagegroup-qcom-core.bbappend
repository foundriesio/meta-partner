# Disable inclusion of the usb recipe by default (sets and depends on adb)
USB = 'False'
