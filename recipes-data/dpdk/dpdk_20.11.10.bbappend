# Fix incorrect license from meta-qcom-hwe
LICENSE = "BSD-3-Clause | LGPL-2.1-only | GPL-2.0-only"
